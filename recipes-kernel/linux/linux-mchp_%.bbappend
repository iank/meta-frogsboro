FILESEXTRAPATHS_prepend := "${THISDIR}/linux-mchp:"
SRC_URI += "file://fragment.cfg"
