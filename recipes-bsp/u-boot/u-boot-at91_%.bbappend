FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://sam9x60ek-sd-frogsboro.txt;subdir=envs/"
