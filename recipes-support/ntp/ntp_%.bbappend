FILESEXTRAPATHS_prepend := "${THISDIR}/ntp:"
SRC_URI += "file://ntp.conf"
